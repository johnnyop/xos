# Keil uVision project xos.uvproj, settings and files
target xos (MCS-51)
  device: STC12C5A60S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: xos +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;.\inc\xlib;.\inc\kernel
  asm include: .\inc
  group test
    ./src/: test.c
  group xos
    ./src/kernel/: xos.c kernel.c sem.c STARTUP.A51
  group xlib
    ./src/kernel/: xlib.c
    ./src/xlib/: 1602.c 12864.c stcad.c uart.c
